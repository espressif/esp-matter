## examples/all_device_types_app/sdkconfig.defaults.esp32s31
```kconfig
# use for otbr option
CONFIG_LWIP_IPV6_NUM_ADDRESSES=8

CONFIG_ESP_WIFI_SOFTAP_SUPPORT=y
```
