# Keil uVision project libminisupp_wps.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MT7687F MediaTek
  pack: MediaTek.MTx.4.2.0
  cpu: IROM(0x10000000,0x00200000) IRAM(0x20000000,0x00040000) IRAM2(0x00100000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: libminisupp_wps_CM4_Keil (library)
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: __VFP_FP__ _REENT_SMALL MTK_SMTCN_ENABLE MTK_MINISUPP_ENABLE MTK_MINICLI_ENABLE MTK_PING_OUT_ENABLE MTK_IPERF_ENABLE MTK_BSPEXT_ENABLE  MTK_FOTA_ENABLE MTK_FOTA_ON_7687 MTK_HAL_LOWPOWER_ENABLE MTK_LWIP_ENABLE  LXR_NVDM_SUP MTK_MINISUPP_ENABLE OS_NO_C_LIB_DEFINES CONFIG_DRIVER_NONE CONFIG_DRIVER_INBAND CONFIG_AP CONFIG_NO_RADIUS CONFIG_NO_ACCOUNTING CONFIG_NO_VLAN EAP_SERVER EAP_SERVER_IDENTITY CONFIG_CRYPTO_INTERNAL CONFIG_INTERNAL_LIBTOMMATH CONFIG_NO_RANDOM_POOL CONFIG_WPS2 CONFIG_WPS EAP_WSC IEEE8021X_EAPOL EAP_SERVER_WSC CONFIG_SHA256 MTK_WIFI_WPS_ENABLE MTK_CLI_TEST_MODE_ENABLE MTK_WIFI_REPEATER_ENABLE CONFIG_REPEATER MTK_DEBUG_LEVEL_ERROR MTK_NVDM_ENABLE
  c misc: --diag_suppress=1,188,381
  c include: ..\..\..\..\..\..\middleware\MTK\minisupp\src_protected\wpa_supplicant_8.jb4_1\src\utils;..\..\..\..\..\..\middleware\third_party\lwip\src\include;..\..\..\..\..\..\project\mt7687_hdk\apps\iot_sdk\inc;..\..\..\..\..\..\kernel\rtos\FreeRTOS\inc;..\..\..\..\..\..\kernel\service\inc;..\..\..\..\..\..\middleware\third_party\lwip\ports\include;..\..\..\..\..\..\middleware\MTK\minisupp\src_protected\wpa_supplicant_8.jb4_1\src;..\..\..\..\..\..\driver\chip\mt7687\inc;..\..\..\..\..\..\middleware\MTK\minisupp\inc;..\..\..\..\..\..\middleware\MTK\minicli\inc;..\..\..\..\..\..\middleware\MTK\wifi_service\combo\inc;..\..\..\..\..\..\middleware\MTK\minisupp\src_protected\wpa_supplicant_8.jb4_1\src\drivers;..\..\..\..\..\..\driver\chip\inc;..\..\..\..\..\..\driver\CMSIS\Include;..\..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include;..\..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\..\kernel\rtos\FreeRTOS;..\..\..\..\..\..\driver\board\mt76x7_hdk\inc;..\..\..\..\..\..\middleware\MTK\nvdm\inc;..\..\..\..\..\..\middleware\MTK\connsys\inc
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x100000 size 0x10000
  scatter file: libminisupp.sct
  group common
    ../../: minisupp_cli.c
    ../../wpa_supplicant_8.jb4_1/wpa_supplicant/: ap.c blacklist.c bss.c minisupp_config.c config_nvram.c events.c notify.c scan.c wpa_supplicant.c wpa_supplicant_entry.c wpas_glue.c eap_register.c wpa_supplicant_task.c
    ../../wpa_supplicant_8.jb4_1/src/ap/: ap_config.c ap_drv_ops.c ap_mlme.c authsrv.c beacon.c drv_callbacks.c hostapd.c ieee802_1x.c ieee802_11_auth.c ieee802_11_shared.c pmksa_cache_auth.c sta_info.c tkip_countermeasures.c utils.c wpa_auth.c wpa_auth_glue.c wpa_auth_ie.c
    ../../wpa_supplicant_8.jb4_1/src/common/: ieee802_11_common.c wpa_common.c
    ../../wpa_supplicant_8.jb4_1/src/crypto/: aes-internal.c aes-internal-dec.c aes-internal-enc.c aes-unwrap.c aes-wrap.c crypto_internal.c md5.c md5-internal.c rc4.c sha1.c sha1-internal.c sha1-pbkdf2.c tls_internal.c
    ../../wpa_supplicant_8.jb4_1/src/drivers/: driver_common.c driver_inband.c driver_none.c drivers.c
    ../../wpa_supplicant_8.jb4_1/src/eap_common/: eap_common.c
    ../../wpa_supplicant_8.jb4_1/src/eap_server/: eap_server.c eap_server_identity.c eap_server_methods.c
    ../../wpa_supplicant_8.jb4_1/src/eapol_auth/: eapol_auth_sm.c
    ../../wpa_supplicant_8.jb4_1/src/l2_packet/: l2_packet_freertos.c
    ../../wpa_supplicant_8.jb4_1/src/rsn_supp/: peerkey.c pmksa_cache.c preauth.c wpa.c wpa_ie.c
    ../../wpa_supplicant_8.jb4_1/src/utils/: common.c eloop.c ip_addr.c os_freertos.c wpa_debug.c wpabuf.c
  group wps
    ../../wpa_supplicant_8.jb4_1/src/ap/: wps_hostapd.c
    ../../wpa_supplicant_8.jb4_1/src/crypto/: aes-cbc.c crypto_internal-modexp.c sha256-internal.c dh_group5.c dh_groups.c sha256.c
    ../../wpa_supplicant_8.jb4_1/src/eap_common/: eap_wsc_common.c
    ../../wpa_supplicant_8.jb4_1/src/eap_peer/: eap_wsc.c eap.c eap_methods.c
    ../../wpa_supplicant_8.jb4_1/src/eap_server/: eap_server_wsc.c
    ../../wpa_supplicant_8.jb4_1/src/eapol_supp/: eapol_supp_sm.c
    ../../wpa_supplicant_8.jb4_1/src/tls/: bignum.c
    ../../wpa_supplicant_8.jb4_1/src/utils/: uuid.c base64.c
    ../../wpa_supplicant_8.jb4_1/src/wps/: wps_registrar.c wps.c wps_attr_build.c wps_attr_parse.c wps_attr_process.c wps_common.c wps_dev_attr.c wps_enrollee.c
    ../../wpa_supplicant_8.jb4_1/wpa_supplicant/: wps_supplicant.c
