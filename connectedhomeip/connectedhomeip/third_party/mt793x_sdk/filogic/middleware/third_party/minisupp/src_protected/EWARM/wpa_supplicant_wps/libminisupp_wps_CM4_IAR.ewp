# IAR project libminisupp_wps_CM4_IAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __VFP_FP__; _REENT_SMALL; MTK_SMTCN_ENABLE; MTK_MINISUPP_ENABLE; MTK_MINICLI_ENABLE; MTK_PING_OUT_ENABLE; MTK_IPERF_ENABLE; MTK_BSPEXT_ENABLE; MTK_FOTA_ENABLE; MTK_FOTA_ON_7687; MTK_HAL_LOWPOWER_ENABLE; MTK_LWIP_ENABLE; LXR_NVDM_SUP; OS_NO_C_LIB_DEFINES; CONFIG_DRIVER_NONE; CONFIG_DRIVER_INBAND; CONFIG_AP; CONFIG_NO_RADIUS; CONFIG_NO_ACCOUNTING; CONFIG_NO_VLAN; EAP_SERVER; EAP_SERVER_IDENTITY; CONFIG_CRYPTO_INTERNAL; CONFIG_INTERNAL_LIBTOMMATH; CONFIG_NO_RANDOM_POOL; CONFIG_WPS2; CONFIG_WPS; EAP_WSC; IEEE8021X_EAPOL; EAP_SERVER_WSC; CONFIG_SHA256; MTK_WIFI_WPS_ENABLE; MTK_CLI_TEST_MODE_ENABLE; MTK_WIFI_REPEATER_ENABLE; CONFIG_REPEATER; MTK_DEBUG_LEVEL_ERROR; MTK_NVDM_ENABLE
  ICCARM.CCDiagSuppress: Pa050,Ta022,Ta023,Pe188,Pe021,Pe381
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\middleware\MTK\minisupp\src_protected\wpa_supplicant_8.jb4_1\src\utils; ..\..\..\..\..\..\middleware\third_party\lwip\src\include; ..\..\..\..\..\..\project\mt7687_hdk\apps\iot_sdk\inc; ..\..\..\..\..\..\kernel\rtos\FreeRTOS\inc; ..\..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\..\middleware\third_party\lwip\ports\include; ..\..\..\..\..\..\middleware\MTK\minisupp\src_protected\wpa_supplicant_8.jb4_1\src; ..\..\..\..\..\..\driver\chip\mt7687\inc; ..\..\..\..\..\..\middleware\MTK\minisupp\inc; ..\..\..\..\..\..\middleware\MTK\minicli\inc; ..\..\..\..\..\..\middleware\MTK\wifi_service\combo\inc; ..\..\..\..\..\..\middleware\MTK\minisupp\src_protected\wpa_supplicant_8.jb4_1\src\drivers; ..\..\..\..\..\..\driver\chip\inc; ..\..\..\..\..\..\driver\CMSIS\Include; ..\..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include; ..\..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\..\kernel\rtos\FreeRTOS; ..\..\..\..\..\..\driver\board\mt76x7_hdk\inc; ..\..\..\..\..\..\middleware\MTK\nvdm\inc; ..\..\..\..\..\..\middleware\MTK\minisupp\src_protected\wpa_supplicant_8.jb4_1\src\utils; ..\..\..\..\..\..\driver\CMSIS\Device\MTK\mt7687\Include; ..\..\..\..\..\..\middleware\MTK\connsys\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: crypto.bin
  ILINK.IlinkOutputFile: i2c_communication_with_EEPROM_polling.out
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group common
    ../../wpa_supplicant_8.jb4_1/src/crypto/: aes-internal-dec.c aes-internal-enc.c aes-internal.c aes-unwrap.c aes-wrap.c crypto_internal.c md5-internal.c md5.c rc4.c sha1-internal.c sha1-pbkdf2.c sha1.c tls_internal.c
    ../../wpa_supplicant_8.jb4_1/wpa_supplicant/: ap.c blacklist.c bss.c config_nvram.c eap_register.c events.c minisupp_config.c notify.c scan.c wpa_supplicant.c wpa_supplicant_entry.c wpa_supplicant_task.c wpas_glue.c
    ../../wpa_supplicant_8.jb4_1/src/ap/: ap_config.c ap_drv_ops.c ap_mlme.c authsrv.c beacon.c drv_callbacks.c hostapd.c ieee802_11_auth.c ieee802_11_shared.c ieee802_1x.c pmksa_cache_auth.c sta_info.c tkip_countermeasures.c utils.c wpa_auth.c wpa_auth_glue.c wpa_auth_ie.c
    ../../wpa_supplicant_8.jb4_1/src/utils/: common.c eloop.c ip_addr.c os_freertos.c wpa_debug.c wpabuf.c
    ../../wpa_supplicant_8.jb4_1/src/drivers/: driver_common.c driver_inband.c driver_none.c drivers.c
    ../../wpa_supplicant_8.jb4_1/src/eap_common/: eap_common.c
    ../../wpa_supplicant_8.jb4_1/src/eap_server/: eap_server.c eap_server_identity.c eap_server_methods.c
    ../../wpa_supplicant_8.jb4_1/src/eapol_auth/: eapol_auth_sm.c
    ../../wpa_supplicant_8.jb4_1/src/common/: ieee802_11_common.c wpa_common.c
    ../../wpa_supplicant_8.jb4_1/src/l2_packet/: l2_packet_freertos.c
    ../../: minisupp_cli.c
    ../../wpa_supplicant_8.jb4_1/src/rsn_supp/: peerkey.c pmksa_cache.c preauth.c wpa.c wpa_ie.c
  group wps
    ../../wpa_supplicant_8.jb4_1/src/crypto/: aes-cbc.c crypto_internal-modexp.c dh_group5.c dh_groups.c sha256-internal.c sha256.c
    ../../wpa_supplicant_8.jb4_1/src/utils/: base64.c uuid.c
    ../../wpa_supplicant_8.jb4_1/src/tls/: bignum.c
    ../../wpa_supplicant_8.jb4_1/src/eap_peer/: eap.c eap_methods.c eap_wsc.c
    ../../wpa_supplicant_8.jb4_1/src/eap_server/: eap_server_wsc.c
    ../../wpa_supplicant_8.jb4_1/src/eap_common/: eap_wsc_common.c
    ../../wpa_supplicant_8.jb4_1/src/eapol_supp/: eapol_supp_sm.c
    ../../wpa_supplicant_8.jb4_1/src/wps/: wps.c wps_attr_build.c wps_attr_parse.c wps_attr_process.c wps_common.c wps_dev_attr.c wps_enrollee.c wps_registrar.c
    ../../wpa_supplicant_8.jb4_1/src/ap/: wps_hostapd.c
    ../../wpa_supplicant_8.jb4_1/wpa_supplicant/: wps_supplicant.c
