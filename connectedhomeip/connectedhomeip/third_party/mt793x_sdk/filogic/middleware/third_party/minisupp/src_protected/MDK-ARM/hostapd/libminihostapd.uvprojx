# Keil uVision project libminihostapd.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MT7687F MediaTek
  pack: MediaTek.MT7687.1.2.1
  cpu: IROM(0x10000000,0x00400000) IRAM(0x20000000,0x00040000) IRAM2(0x00100000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: libminisupp (library)
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: ..\..\..\..\middleware\MTK\minisupp\src\wpa_supplicant_8.jb4_1\src\utils;..\..\..\..\middleware\third_party\lwip\src\include;..\..\..\..\project\mt7687_hdk\apps\iot_sdk\inc;..\..\..\..\kernel\rtos\FreeRTOS\inc;..\..\..\..\kernel\service\inc;..\..\..\..\middleware\third_party\lwip\ports\include;..\..\..\..\middleware\MTK\minisupp\src\wpa_supplicant_8.jb4_1\src;..\..\..\..\driver\chip\mt7687\inc
  memory RVCT4: ROM 0x10000000 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x100000 size 0x10000
  group src
    ../../src/: minisupp_cli.c
    ../../src/wpa_supplicant_8.jb4_1/hostapd/: nt_password_hash.c dump_state.c hlr_auc_gw.c hostapd_cli.c hostapd_entry.c
    ../../src/wpa_supplicant_8.jb4_1/wpa_supplicant/: wps_supplicant.c ap.c bgscan.c bgscan_learn.c bgscan_simple.c blacklist.c bss.c config.c config_none.c config_nvram.c config_static.c config_winreg.c ctrl_iface_named_pipe.c ctrl_iface_udp.c ctrl_iface_unix.c eapol_test.c events.c gas_query.c ibss_rsn.c interworking.c main_none.c main_winmain.c main_winsvc.c notify.c offchannel.c p2p_supplicant.c preauth_test.c scan.c sme.c win_if_list.c wpa_cli.c wpa_passphrase.c wpa_priv.c wpa_supplicant.c wpa_supplicant_entry.c wpas_glue.c config_file.c ctrl_iface.c eap_register.c main.c
    ../../src/wpa_supplicant_8.jb4_1/wpa_supplicant/dbus/: dbus_old_handlers_wps.c dbus_common.c dbus_dict_helpers.c dbus_new.c dbus_new_handlers.c dbus_new_handlers_p2p.c dbus_new_handlers_wps.c dbus_new_helpers.c dbus_new_introspect.c dbus_old.c dbus_old_handlers.c
    ../../src/wpa_supplicant_8.jb4_1/src/ap/: accounting.c ap_config.c ap_drv_ops.c ap_list.c ap_mlme.c authsrv.c beacon.c ctrl_iface_ap.c drv_callbacks.c hostapd.c hw_features.c iapp.c ieee802_1x.c ieee802_11.c ieee802_11_auth.c ieee802_11_ht.c ieee802_11_shared.c p2p_hostapd.c peerkey_auth.c pmksa_cache_auth.c preauth_auth.c sta_info.c tkip_countermeasures.c utils.c vlan_init.c wpa_auth.c wmm.c wpa_auth_ft.c wpa_auth_glue.c wpa_auth_ie.c wps_hostapd.c
    ../../src/wpa_supplicant_8.jb4_1/src/common/: gas.c ieee802_11_common.c wpa_common.c wpa_ctrl.c
    ../../src/wpa_supplicant_8.jb4_1/src/crypto/: aes-cbc.c aes-ctr.c aes-eax.c aes-encblock.c aes-internal.c aes-internal-dec.c aes-internal-enc.c aes-omac1.c aes-unwrap.c aes-wrap.c crypto_cryptoapi.c crypto_gnutls.c crypto_internal.c crypto_internal-cipher.c crypto_internal-modexp.c crypto_internal-rsa.c crypto_libtomcrypt.c crypto_none.c crypto_nss.c crypto_openssl.c des-internal.c dh_group5.c dh_groups.c fips_prf_cryptoapi.c fips_prf_gnutls.c fips_prf_internal.c fips_prf_nss.c fips_prf_openssl.c md4-internal.c md5.c md5-internal.c md5-non-fips.c milenage.c ms_funcs.c random.c rc4.c sha1.c sha1-internal.c sha1-pbkdf2.c sha1-tlsprf.c sha1-tprf.c sha256.c sha256-internal.c sha256-tlsprf.c tls_gnutls.c tls_internal.c tls_none.c tls_nss.c tls_openssl.c tls_schannel.c
    ../../src/wpa_supplicant_8.jb4_1/src/drivers/deprecated/: driver_atheros.c driver_bsd.c driver_hostap.c driver_madwifi.c driver_ndis.c driver_ndis_.c driver_privsep.c driver_roboswitch.c driver_test.c driver_wext.c driver_wired.c
    ../../src/wpa_supplicant_8.jb4_1/src/drivers/: rfkill.c driver_common.c driver_inband.c driver_nl80211.c driver_none.c drivers.c linux_ioctl.c ndis_events.c netlink.c
    ../../src/wpa_supplicant_8.jb4_1/src/eap_common/: chap.c eap_common.c eap_fast_common.c eap_gpsk_common.c eap_ikev2_common.c eap_pax_common.c eap_peap_common.c eap_psk_common.c eap_pwd_common.c eap_sake_common.c eap_sim_common.c eap_wsc_common.c ikev2_common.c
    ../../src/wpa_supplicant_8.jb4_1/src/eap_peer/: eap.c eap_aka.c eap_fast.c eap_fast_pac.c eap_gpsk.c eap_gtc.c eap_ikev2.c eap_leap.c eap_md5.c eap_methods.c eap_mschapv2.c eap_otp.c eap_pax.c eap_peap.c eap_psk.c eap_pwd.c eap_sake.c eap_sim.c eap_tls.c eap_tls_common.c eap_tnc.c eap_ttls.c eap_vendor_test.c eap_wsc.c mschapv2.c tncc.c ikev2.c
    ../../src/wpa_supplicant_8.jb4_1/src/eap_server/: eap_server.c eap_server_aka.c eap_server_fast.c eap_server_gpsk.c eap_server_gtc.c eap_server_identity.c eap_server_ikev2.c eap_server_md5.c eap_server_methods.c eap_server_mschapv2.c eap_server_pax.c eap_server_peap.c eap_server_psk.c eap_server_pwd.c eap_server_sake.c eap_server_sim.c eap_server_tls.c eap_server_tls_common.c eap_server_tnc.c eap_server_ttls.c eap_server_vendor_test.c eap_server_wsc.c eap_sim_db.c tncs.c
    ../../src/wpa_supplicant_8.jb4_1/src/eapol_auth/: eapol_auth_dump.c eapol_auth_sm.c
    ../../src/wpa_supplicant_8.jb4_1/src/eapol_supp/: eapol_supp_sm.c
    ../../src/wpa_supplicant_8.jb4_1/src/l2_packet/: l2_packet_freebsd.c l2_packet_freertos.c l2_packet_linux.c l2_packet_ndis.c l2_packet_none.c l2_packet_pcap.c l2_packet_privsep.c l2_packet_winpcap.c
    ../../src/wpa_supplicant_8.jb4_1/src/p2p/: p2p.c p2p_build.c p2p_dev_disc.c p2p_go_neg.c p2p_group.c p2p_invitation.c p2p_parse.c p2p_pd.c p2p_sd.c p2p_utils.c
    ../../src/wpa_supplicant_8.jb4_1/src/radius/: radius.c radius_client.c radius_server.c
    ../../src/wpa_supplicant_8.jb4_1/src/rsn_supp/: peerkey.c pmksa_cache.c preauth.c tdls.c wpa.c wpa_ft.c wpa_ie.c
    ../../src/wpa_supplicant_8.jb4_1/src/tls/: asn1.c bignum.c libtommath.c pkcs1.c pkcs5.c pkcs8.c rsa.c tlsv1_client.c tlsv1_client_read.c tlsv1_client_write.c tlsv1_common.c tlsv1_cred.c tlsv1_record.c tlsv1_server.c tlsv1_server_read.c tlsv1_server_write.c x509v3.c
    ../../src/wpa_supplicant_8.jb4_1/src/utils/: base64.c common.c edit.c edit_readline.c edit_simple.c eloop.c eloop_none.c eloop_win.c ip_addr.c os_freertos.c os_internal.c os_none.c os_unix.c os_win32.c pcsc_funcs.c radiotap.c trace.c uuid.c wpa_debug.c wpabuf.c
    ../../src/wpa_supplicant_8.jb4_1/src/wps/: http_client.c http_server.c httpread.c ndef.c upnp_xml.c wps.c wps_attr_build.c wps_attr_parse.c wps_attr_process.c wps_common.c wps_dev_attr.c wps_enrollee.c wps_er.c wps_er_ssdp.c wps_nfc.c wps_nfc_pn531.c wps_registrar.c wps_ufd.c wps_upnp.c wps_upnp_ap.c wps_upnp_event.c wps_upnp_ssdp.c wps_upnp_web.c wps_validate.c
    ../../src/wpa_supplicant_8.jb4_1/wpa_supplicant/tests/: link_test.c test_eap_sim_common.c test_wpa.c
