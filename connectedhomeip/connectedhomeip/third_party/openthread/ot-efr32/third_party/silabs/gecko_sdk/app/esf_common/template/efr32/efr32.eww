<?xml version="1.0" encoding="iso-8859-1"?>
<!-- This file was generated by Simplicity Studio from the following template:
       app/esf_common/template/efr32/efr32.eww
     Please do not edit it directly.
-->

<workspace>
  <project>
    <path>$WS_DIR$\$--deviceName--$.ewp</path>
  </project>
  <batchBuild/>
</workspace>
