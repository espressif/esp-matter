# IAR project stm32f103ret.ewp, settings and files
configuration Normal (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  ICCARM.CCDefines: EMBER_SERIAL_USE_STDIO; HAL_HOST; STM32F10X_HD; USE_STDPERIPH_DRIVER; CONFIGURATION_HEADER="$--generatedHeader--$"; PLATFORM_HEADER="$--halDirFromStackFs--$/host/cortexm3/stm32f103ret/compiler/iar-st.h"; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; $--stackDirFromProjBs--$; $--frameworkDirFromProjBs--$\..\..; $--frameworkDirFromProjBs--$\..\..\stack; $--frameworkDirFromProjBs--$\..\util; $--halDirFromProjBs--$; $--halDirFromProjBs--$\plugin; $--halDirFromProjBs--$\..; $--halDirFromProjBs--$\host\cortexm3\stm32f103ret; $--halDirFromProjBs--$\host\cortexm3\stm32f103ret\Libraries\CMSIS\CM3\CoreSupport; $--halDirFromProjBs--$\host\cortexm3\stm32f103ret\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; $--halDirFromProjBs--$\host\cortexm3\stm32f103ret\Libraries\STM32F10x_StdPeriph_Driver\inc; $--stackDirFromProjBs--$\..\..\util\silicon_labs\silabs_core; $--halDirFromProjBs--$\..\..\common\inc; $--halDirFromProjBs--$\..\..\radio\mac
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: EMBER_SERIAL_USE_STDIO; HAL_HOST; STM32F10X_HD; USE_STDPERIPH_DRIVER; CONFIGURATION_HEADER="$--generatedHeader--$"; PLATFORM_HEADER="$--halDirFromStackFs--$/host/cortexm3/stm32f103ret/compiler/iar-st.h"
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: $--deviceName--$.s37
  ILINK.IlinkOutputFile: $--deviceName--$.out
  ILINK.IlinkIcfFile: $--halDirFromProjBs--$\host\cortexm3\stm32f103ret\iar-cfg-st.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
