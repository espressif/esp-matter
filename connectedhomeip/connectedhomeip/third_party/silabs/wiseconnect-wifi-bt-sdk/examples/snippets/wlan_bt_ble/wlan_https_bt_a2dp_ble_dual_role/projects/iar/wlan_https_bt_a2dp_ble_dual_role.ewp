# IAR project wlan_https_bt_a2dp_ble_dual_role.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT595S_M33 NXP MIMXRT595S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: __ICCARM__; DEBUG; CPU_MIMXRT595SFFOA_cm33; BOOT_HEADER_ENABLE=1; CR_INTEGER_PRINTF; ARM_MATH_CM33; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; FREEDOM; PRINTF_FLOAT_ENABLE=0; MXRT_595s; RSI_SAMPLE_HAL; SDK_DEBUGCONSOLE=1; RSI_BT_ENABLE; RSI_WLAN_ENABLE; RSI_BLE_ENABLE; RSI_SDIO_INTERFACE; MXRT_595s; SDK_I2C_BASED_COMPONENT_USED=1; RSI_DEBUG_PRINTS; RSI_WITH_OS
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.IExtraOptions: --diag_suppress Pa093,Pe301,Pa082,Pa084,Pe177,Pe549,Pe161,Pa182,Pe186,Pe068,Pe111,Pe236,Pe120,Pe223,Pe188,Pe550,Pe167
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\sapi\include; ..\..\..\..\..\..\sapi\rom; ..\..\..\..\..\..\sapi\network\protocols; ..\..\..\..\..\..\sapi\network\protocols\http_server; ..\..\..\..\..\..\sapi\bluetooth; ..\..\..\..\..\..\third_party\sbc_audio_codec\inc; ..\..\..\..\..\..\third_party\mqtt_client\src; ..\..\..\..\..\..\third_party\mqtt_client\src\MQTTPacket\src; ..\..\..\..\..\utilities\certificates; ..\..; ..\..\platforms\nxp\rt595\rtos; ..\..\platforms\nxp\rt595\CMSIS\Include; ..\..\platforms\nxp\rt595\devices; ..\..\platforms\nxp\rt595\devices\MIMXRT595S\drivers; ..\..\platforms\nxp\rt595\devices\MIMXRT595S; ..\..\platforms\nxp\rt595\devices\MIMXRT595S\utilities\str; ..\..\platforms\nxp\rt595\devices\MIMXRT595S\utilities\debug_console; ..\..\platforms\nxp\rt595\components\uart; ..\..\platforms\nxp\rt595\components\serial_manager; ..\..\platforms\nxp\rt595\components\pca9420; ..\..\platforms\nxp\rt595\components\lists; ..\..\platforms\nxp\rt595\devices\MIMXRT595S\cmsis_drivers; ..\..\platforms\nxp\rt595\middleware\fatfs; ..\..\platforms\nxp\rt595\middleware\sdmmc\inc; ..\..\platforms\nxp\rt595\middleware\sdmmc\port\usdhc\freertos; ..\..\platforms\nxp\rt595\middleware\fatfs\source\fsl_sd_disk; ..\..\platforms\nxp\rt595\middleware\sdmmc\port; ..\..\platforms\nxp\rt595\middleware\fatfs\source; ..\..\platforms\nxp\rt595\rtos\amazon-freertos\lib\FreeRTOS\portable\IAR\ARM_CM33_NTZ\non_secure; ..\..\platforms\nxp\rt595\rtos\amazon-freertos\lib\include\private; ..\..\platforms\nxp\rt595\rtos\amazon-freertos\lib\include; ..\..\platforms\nxp\rt595\rtos\amazon-freertos\lib\FreeRTOS\portable; ..\..\platforms\nxp\rt595\board; ..\..\platforms\nxp\rt595\devices\MIMXRT595S\iar; ..\..\platforms\nxp\rt595\rtos\amazon-freertos\lib\FreeRTOS\portable\IAR\ARM_CM33_NTZ\non_secure
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..\..\platforms\nxp\rt595\rtos
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  ILINK.IlinkOutputFile: bt_a2dp_source.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1600; __heap_size__=0x1600
  ILINK.IlinkIcfFile: MIMXRT595Sxxxx_cm33_ram.icf
  ILINK.IlinkAdditionalLibs: ..\..\platforms\nxp\rt595\devices\MIMXRT595S\iar\iar_lib_power.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 58
  ICCARM.CCDefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; BOOT_HEADER_ENABLE=1; CPU_MIMXRT595SFFOA_cm33; ARM_MATH_CM33; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; FSL_RTOS_FREE_RTOS
  ICCARM.CCIncludePath2: ..; ../../..; ../../CMSIS/Include; ../../devices; ../../devices/MIMXRT595S/drivers; ../../devices/MIMXRT595S/drivers; ../../devices/MIMXRT595S/drivers; ../../devices/MIMXRT595S/drivers; ../../devices/MIMXRT595S/xip; ../../devices/MIMXRT595S; ../../devices/MIMXRT595S/utilities/str; ../../devices/MIMXRT595S/utilities/debug_console; ../../components/uart; ../../devices/MIMXRT595S/drivers; ../../devices/MIMXRT595S/drivers; ../../components/serial_manager; ../../components/serial_manager; ../../devices/MIMXRT595S/drivers; ../../components/lists; ../../devices/MIMXRT595S/drivers; ../../devices/MIMXRT595S/drivers; ../../devices/MIMXRT595S/drivers; ../../devices/MIMXRT595S/drivers
  ICCARM.CCOptLevel: 1
  ILINK.IlinkOutputFile: hello_world.out
  ILINK.IlinkIcfFile: MIMXRT595Sxxxx_cm33_flash.icf
  ILINK.IlinkAdditionalLibs: ../../devices/MIMXRT595S/iar/iar_lib_power.a
configuration release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 58
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT595SFFOA_cm33; BOOT_HEADER_ENABLE=1; ARM_MATH_CM33
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  ILINK.IlinkOutputFile: hello_world.out
  ILINK.IlinkIcfFile: MIMXRT595Sxxxx_cm33_ram.icf
  ILINK.IlinkAdditionalLibs: ../../devices/MIMXRT595S/iar/iar_lib_power.a
configuration flash_release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 58
  ICCARM.CCDefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMXRT595SFFOA_cm33; BOOT_HEADER_ENABLE=1; NDEBUG; ARM_MATH_CM33
  ICCARM.CCIncludePath2: ..; ../../..; ../../CMSIS/Include; ../../devices; ../../devices/MIMXRT595S/drivers; ../../devices/MIMXRT595S/xip; ../../devices/MIMXRT595S; ../../devices/MIMXRT595S/utilities/str; ../../devices/MIMXRT595S/utilities/debug_console; ../../components/uart; ../../devices/MIMXRT595S/drivers; ../../devices/MIMXRT595S/drivers; ../../components/serial_manager; ../../components/serial_manager; ../../devices/MIMXRT595S/drivers; ../../components/lists; ../../devices/MIMXRT595S/drivers
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: hello_world.out
  ILINK.IlinkIcfFile: MIMXRT595Sxxxx_cm33_flash.icf
  ILINK.IlinkAdditionalLibs: ../../devices/MIMXRT595S/iar/iar_lib_power.a
  group examples
    ../../: dltest.txt dltestdata32.txt main.c pcm_data_buff.h Readme.txt rsi_ble_config.h rsi_ble_device_info.c rsi_ble_device_info.h rsi_ble_main_task.c rsi_ble_subtasks.c rsi_bt_a2dp_source_avrcp.c rsi_bt_config.h rsi_common_app.c rsi_common_app.h rsi_common_config.h rsi_lk_save.c rsi_sock_test.c rsi_sock_test.h rsi_wlan_config.h rsi_wlan_http_s.c
  group platforms/board
    ../../platforms/nxp/rt595/board/: board.c board.h clock_config.c clock_config.h ffconf.h pin_mux.c pin_mux.h pin_mux_sdcard.c pin_mux_sdio.h rsi_board_configuration.h RTE_Device.h
  group platforms/CMSIS
    ../../platforms/nxp/rt595/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm7.h core_dsp.h core_sc000.h core_sc300.h Driver_CAN.h Driver_Common.h Driver_ETH.h Driver_ETH_MAC.h Driver_ETH_PHY.h Driver_Flash.h Driver_I2C.h Driver_MCI.h Driver_NAND.h Driver_SAI.h Driver_SPI.h Driver_USART.h Driver_USB.h Driver_USBD.h Driver_USBH.h Driver_WiFi.h mpu_armv7.h mpu_armv8.h tz_context.h
  group platforms/component/lists
    ../../platforms/nxp/rt595/components/lists/: generic_list.c generic_list.h
  group platforms/component/serial_manager
    ../../platforms/nxp/rt595/components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group platforms/component/uart
    ../../platforms/nxp/rt595/components/uart/: uart.h usart_adapter.c
  group platforms/device
    ../../platforms/nxp/rt595/devices/MIMXRT595S/: fsl_device_registers.h MIMXRT595S_cm33.h MIMXRT595S_cm33_features.h system_MIMXRT595S_cm33.c system_MIMXRT595S_cm33.h
  group platforms/drivers
    ../../platforms/nxp/rt595/devices/MIMXRT595S/drivers/: fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_dma.c fsl_dma.h fsl_flexcomm.c fsl_flexcomm.h fsl_flexio_spi.c fsl_flexio_spi.h fsl_flexspi.c fsl_flexspi.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_iap.c fsl_iap.h fsl_inputmux.c fsl_inputmux.h fsl_iopctl.h fsl_mrt.c fsl_mrt.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_spi.c fsl_spi.h fsl_spi_dma.c fsl_spi_dma.h fsl_usart.c fsl_usart.h fsl_usdhc.c fsl_usdhc.h
  group platforms/fatfs
    ../../platforms/nxp/rt595/middleware/fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c
    ../../platforms/nxp/rt595/middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
  group platforms/hal
    ../../platforms/nxp/rt595/hal/: rsi_hal_mcu_interrupt.c rsi_hal_mcu_ioports.c rsi_hal_mcu_platform_init.c rsi_hal_mcu_random.c rsi_hal_mcu_sdio.c rsi_hal_mcu_spi.c rsi_hal_mcu_timer.c rsi_hal_mcu_uart.c
  group platforms/http_client
    ../../platforms/nxp/rt595/components/pca9420/: fsl_pca9420.c fsl_pca9420.h
  group platforms/rtos/amazon-freertos
    ../../platforms/nxp/rt595/rtos/: FreeRTOSConfig.h
  group platforms/rtos/amazon-freertos/FreeRTOS
    ../../platforms/nxp/rt595/rtos/amazon-freertos/lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group platforms/rtos/amazon-freertos/FreeRTOS/portable
    ../../platforms/nxp/rt595/rtos/amazon-freertos/lib/FreeRTOS/portable/MemMang/: heap_4.c
    ../../platforms/nxp/rt595/rtos/amazon-freertos/lib/FreeRTOS/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.h portasm.s portmacro.h
  group platforms/sdmmc/inc
    ../../platforms/nxp/rt595/middleware/sdmmc/inc/: fsl_mmc.h fsl_sd.h fsl_sdio.h fsl_sdmmc_common.h fsl_sdmmc_host.h fsl_sdmmc_spec.h
  group platforms/sdmmc/port
    ../../platforms/nxp/rt595/middleware/sdmmc/port/usdhc/freertos/: fsl_sdmmc_event.c fsl_sdmmc_host.c
    ../../platforms/nxp/rt595/middleware/sdmmc/port/: fsl_sdmmc_event.h
  group platforms/sdmmc/src
    ../../platforms/nxp/rt595/middleware/sdmmc/src/: fsl_sd.c fsl_sdio.c fsl_sdmmc_common.c
  group platforms/startup
    ../../platforms/nxp/rt595/devices/MIMXRT595S/iar/: startup_MIMXRT595S_cm33.s
  group platforms/utilities
    ../../platforms/nxp/rt595/devices/MIMXRT595S/utilities/: fsl_assert.c
    ../../platforms/nxp/rt595/devices/MIMXRT595S/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../platforms/nxp/rt595/devices/MIMXRT595S/utilities/str/: fsl_str.c fsl_str.h
  group sapi/bluetooth
    ../../../../../../sapi/bluetooth/: rsi_ble_gap_apis.c rsi_ble_gatt_apis.c rsi_bt_a2dp_apis.c rsi_bt_avrcp_apis.c rsi_bt_common_apis.c rsi_bt_gap_apis.c rsi_bt_sbc_codec.c rsi_bt_spp_apis.c
  group sapi/common
    ../../../../../../sapi/common/: rsi_apis_non_rom.c rsi_apis_rom.c rsi_common_apis.c rsi_device_init_apis.c
  group sapi/driver
    ../../../../../../sapi/driver/: rsi_bt_ble.c rsi_common.c rsi_device_init.c rsi_driver.c rsi_driver_event_handlers.c rsi_events.c rsi_events_rom.c rsi_nwk.c rsi_nwk_rom.c rsi_os_none.c rsi_pkt_mgmt.c rsi_pkt_mgmt_rom.c rsi_queue.c rsi_queue_rom.c rsi_scheduler.c rsi_scheduler_rom.c rsi_setregion_countryinfo.c rsi_timer.c rsi_utils.c rsi_utils_rom.c rsi_wlan.c
  group sapi/driver/device_interface/sdio
    ../../../../../../sapi/driver/device_interface/sdio/: rsi_sdio_frame_rd_wr.c rsi_sdio_iface_init.c rsi_sdio_mem_rd_wr.c rsi_sdio_reg_rd_wr.c
  group sapi/driver/device_interface/spi
    ../../../../../../sapi/driver/device_interface/spi/: rsi_spi_frame_rd_wr.c rsi_spi_functs.c rsi_spi_iface_init.c rsi_spi_mem_rd_wr.c rsi_spi_reg_rd_wr.c
  group sapi/include
    ../../../../../../sapi/include/: rsi_ant.h rsi_apis_rom.h rsi_ble.h rsi_ble_apis.h rsi_ble_common_config.h rsi_bootup_config.h rsi_bt.h rsi_bt_apis.h rsi_bt_common.h rsi_bt_common_apis.h rsi_bt_common_config.h rsi_bt_sbc_codec.h rsi_bt_sdp.h rsi_common.h rsi_common_apis.h rsi_crypto.h rsi_data_types.h rsi_driver.h rsi_error.h rsi_events.h rsi_hal.h rsi_hid.h rsi_iap.h rsi_mac_api.h rsi_mac_interface.h rsi_nwk.h rsi_os.h rsi_pkt_mgmt.h rsi_puf.h rsi_qspi_defines.h rsi_queue.h rsi_scheduler.h rsi_sdio.h rsi_setregion_countryinfo.h rsi_socket.h rsi_spi_cmd.h rsi_spi_intf.h rsi_timer.h rsi_uart.h rsi_user.h rsi_utils.h rsi_wisemcu_hardware_setup.h rsi_wlan.h rsi_wlan_apis.h rsi_wlan_common_config.h rsi_wlan_defines.h rsi_wlan_non_rom.h rsi_zb_api.h rsi_zb_frames.h rsi_zb_interfaces.h rsi_zb_types.h sl_app_logging.h sl_fw_logging.h
  group sapi/logging
    ../../../../../../sapi/logging/: sl_app_logging.c sl_fw_logging.c
  group sapi/network/protocols
    ../../../../../../sapi/network/protocols/: rsi_dhcp_user_class.c rsi_dhcp_user_class.h rsi_dns.c rsi_emb_mqtt_client.c rsi_emb_mqtt_client.h rsi_firmware_upgradation.c rsi_firmware_upgradation.h rsi_ftp.c rsi_http_client.c rsi_http_client.h rsi_http_ota_fw_up.c rsi_mdnsd.c rsi_mdnsd.h rsi_mqtt_client.c rsi_mqtt_client.h rsi_multicast.c rsi_multicast.h rsi_ota_fw_up.c rsi_pop3_client.c rsi_pop3_client.h rsi_raw_data.c rsi_smtp_client.c rsi_smtp_client.h rsi_sntp_client.c rsi_sntp_client.h rsi_web_socket.c rsi_web_socket.h
  group sapi/network/protocols/http_server
    ../../../../../../sapi/network/protocols/http_server/: rsi_http_server.c rsi_json_handlers.c rsi_json_handlers.h
  group sapi/network/protocols/mdnsd_records
    ../../../../../../sapi/network/protocols/mdnsd_records/: rsi_mdnsd_records.c rsi_mdnsd_records.h
  group sapi/network/socket
    ../../../../../../sapi/network/socket/: rsi_socket.c rsi_socket_rom.c
  group sapi/rtos/freertos_wrapper
    ../../../../../../sapi/rtos/freertos_wrapper/: rsi_os_wrapper.c
  group sapi/wlan
    ../../../../../../sapi/wlan/: rsi_wlan_apis.c
  group third_party/mqtt_client/src/MQTTPacket
    ../../../../../../third_party/mqtt_client/src/: MQTT_sapi_wrappers.c MQTT_wrappers.h MQTTClient.c MQTTClient.h
  group third_party/mqtt_client/src/MQTTPacket/src
    ../../../../../../third_party/mqtt_client/src/MQTTPacket/src/: MQTTConnect.h MQTTConnectClient.c MQTTDeserializePublish.c MQTTFormat.c MQTTFormat.h MQTTPacket.c MQTTPacket.h MQTTPublish.h MQTTSerializePublish.c MQTTSubscribe.h MQTTSubscribeClient.c MQTTUnsubscribe.h MQTTUnsubscribeClient.c StackTrace.h
  group third_party/sbc_audio_codec/inc
    ../../../../../../third_party/sbc_audio_codec/inc/: ia_apicmd_standards.h ia_error_handler.h ia_error_standards.h ia_memory_standards.h ia_mp3_dec_config_params.h ia_type_def.h integer.h sbc_dct.h sbc_enc_func_declare.h sbc_encoder.h sbc_if.h sbc_types.h
  group third_party/sbc_audio_codec/src
    ../../../../../../third_party/sbc_audio_codec/src/: sbc_analysis.c sbc_dct.c sbc_dct_coeffs.c sbc_enc_bit_alloc_mono.c sbc_enc_bit_alloc_ste.c sbc_enc_coeffs.c sbc_encoder.c sbc_packing.c
  group utilities
    ../../../../../../utilities/advanced_logging/firmware_logging/: firmware_logging_utils.c
