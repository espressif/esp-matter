<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>bt_a2dp_source</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>bt_a2dp_source</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>bt_a2dp_source</project>
        <configuration>flash_debug</configuration>
      </member>
      <member>
        <project>bt_a2dp_source</project>
        <configuration>flash_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>bt_a2dp_source</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>bt_a2dp_source</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flash_debug</name>
      <member>
        <project>bt_a2dp_source</project>
        <configuration>flash_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flash_release</name>
      <member>
        <project>bt_a2dp_source</project>
        <configuration>flash_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/bt_a2dp_source.ewp</path>
  </project>
</workspace>
