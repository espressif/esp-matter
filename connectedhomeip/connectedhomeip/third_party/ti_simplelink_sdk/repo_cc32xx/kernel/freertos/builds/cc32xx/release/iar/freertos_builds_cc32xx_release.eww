<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/freertos_builds_cc32xx_release.ewp</path>
  </project>
  <batchBuild/>
</workspace>
