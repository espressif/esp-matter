<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/freertos_builds_cc13x4_cc26x4_release.ewp</path>
  </project>
  <batchBuild/>
</workspace>
