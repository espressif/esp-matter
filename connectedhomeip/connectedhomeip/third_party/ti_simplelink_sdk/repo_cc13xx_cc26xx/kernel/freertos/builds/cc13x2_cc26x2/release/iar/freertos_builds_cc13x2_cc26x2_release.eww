<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/freertos_builds_cc13x2_cc26x2_release.ewp</path>
  </project>
  <batchBuild/>
</workspace>
