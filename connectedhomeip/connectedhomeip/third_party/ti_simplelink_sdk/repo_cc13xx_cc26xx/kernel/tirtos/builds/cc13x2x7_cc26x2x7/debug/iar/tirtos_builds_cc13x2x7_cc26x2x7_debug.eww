<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/tirtos_builds_cc13x2x7_cc26x2x7_debug.ewp</path>
  </project>
  <batchBuild/>
</workspace>
