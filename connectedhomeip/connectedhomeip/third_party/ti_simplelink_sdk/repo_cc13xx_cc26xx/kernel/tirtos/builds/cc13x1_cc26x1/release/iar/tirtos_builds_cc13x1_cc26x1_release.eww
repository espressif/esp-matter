<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/tirtos_builds_cc13x1_cc26x1_release.ewp</path>
  </project>
  <batchBuild/>
</workspace>
