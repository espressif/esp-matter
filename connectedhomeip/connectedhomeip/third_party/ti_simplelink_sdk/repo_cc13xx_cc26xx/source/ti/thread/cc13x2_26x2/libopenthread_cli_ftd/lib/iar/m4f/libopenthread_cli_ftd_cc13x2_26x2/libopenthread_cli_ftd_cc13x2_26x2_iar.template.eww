<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/libopenthread_cli_ftd_cc13x2_26x2_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>