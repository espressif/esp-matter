<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/simple_mesh_node_oad_onchip_LP_CC2652R7_tirtos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>