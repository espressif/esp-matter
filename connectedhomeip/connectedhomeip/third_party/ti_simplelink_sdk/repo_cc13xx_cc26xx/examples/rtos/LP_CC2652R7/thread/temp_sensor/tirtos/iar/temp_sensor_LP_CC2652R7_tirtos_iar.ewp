# IAR project temp_sensor_LP_CC2652R7_tirtos_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  group (top)
    ./: temp_sensor_LP_CC2652R7_tirtos_iar.ipcf SysConfig_Generated_Files.ipcf release.cfg
